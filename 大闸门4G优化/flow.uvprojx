# Keil uVision project flow.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F207ZG GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.6.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flow
  AfterMake: F:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output Objects/@L.bin Objects/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: .\GD32F20x_standard_peripheral\Include;.\Application;D:\Users\16942\AppData\Local\Arm\Packs\ARM\CMSIS\4.3.0\CMSIS\Include;.\BSP;.\SYSTEM\RTC;.\HMI_DRIVE;.\data;.\FreeRTOS\include;.\FreeRTOS\port\RVDS\ARM_CM3;.\Tasks;.\SYSTEM\sys;.\onenet\inc;.\SYSTEM;.\SYSTEM\delay;.\BSP\W25QXX;.\SYSTEM\spi;.\FATFS;.\MALLOC;.\RTT;..\2023-11-2 161539-驱动器;.\myOTA;.\OTA\inc;.\SYSTEM\gdflash;.\data\cJSON;.\data\Authorization;.\myOnenet;.\TMC5160;.\BSP\LCD;.\BSP\AnglePulse;.\BSP\motor_driver;.\Protocol;.\jiang;.\liu
  memory RVCT4: ROM 0x800c800 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group CMSIS
    ./CMSIS/: system_gd32f20x.c
  group Peripherals
    ./GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group Startup
    ./Startup/: startup_gd32f20x_cl.s
  group Application
    ./Application/: gd32f20x_it.c main.c systick.c FreeRTOSConfig.h test.c
  group BSP
    ./BSP/: i2c.c DS3231.c Bluetooth.c RS232.c RS485.c Hall_Flow.c Relay.c 4GCat1.c L76K.c ultrasonic.c Lora.c power.c motor.c mmc_sd.c LoraMode.c other_bsp.c spi_sd.c spi_sd_dma.c
    ./BSP/W25QXX/: w25qxx.c
    ./BSP/LCD/: LCD.c
    ./BSP/AnglePulse/: AnglePulse.c
    ./BSP/motor_driver/: motor_driver.c
  group SYSTEM
    ./SYSTEM/RTC/: RTC.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/: lowPower.c tims.c wdgt.c
    ./SYSTEM/spi/: spi.c
    ./SYSTEM/flash/: flash.c
    ./SYSTEM/gdflash/: gdflash.c
  group HMI_DRIVE
    ./HMI_DRIVE/: cmd_process.c cmd_queue.c hmi_driver.c hmi_user_uart.c hw_config.c hmi_chart.c
  group DATA
    ./data/: data.c tool.c Dev_data.c flashdata.c rundata.c logdata.c sddata.c printf-stdarg.c onenetdata.c autoControl.c error_data.c watLevSafe.c gd32f20x_rcu_add.c StallGuard.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/port/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/port/MemMang/: heap_4.c
  group Tasks
    ./Tasks/: task1.c gprstask.c
  group ONENET
    ./onenet/src/: base64.c dStream.c fault.c hmac_sha1.c MqttKit.c onenet.c protocol_parser.c
    ./data/cJSON/: cJSON.c
  group ReadMe
    ./ReadMe/: ReadMe.txt GNSS定位坐标计算.txt 数据采集.txt sd卡记录.txt TMC5160A芯片介绍.txt Lora远程控制.c
  group FATFS
    ./FATFS/: diskio.c diskio.h ff.c ff.h ff_user.c ff_user.h ffconf.h ffsystem.c ffunicode.c
  group MALLOC
    ./MALLOC/: malloc.c
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group myOTA
    ./OTA/src/: md5.c
    ./myOTA/: mymd5.c myOTA.c
    ./data/Authorization/: Authorization.c
  group myOnenet
    ./myOnenet/: myOnenet.c
  group TMC5160A
    ./TMC5160/: TMC5160A.c TMC5160.c
  group Protocol
    ./Protocol/: lora_map.c LoraProtocol.c
  group jiang
    ./jiang/: jiang.c middleware.h
  group liu
    ./liu/: liu.c
software components: CMSIS:CORE 5.6.0
